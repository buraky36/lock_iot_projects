## myProjects/1_Access_Control_Terminal/Achieve/ACCESS_Control/sdkconfig.defaults
```kconfig
# Enable Bluetooth for ble_prov.c
CONFIG_BT_ENABLED=y
CONFIG_BT_NIMBLE_ENABLED=y
```
